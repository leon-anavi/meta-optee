RDEPENDS_${PN} += "\
	libteec \
	tee-supplicant \
"

